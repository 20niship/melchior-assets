Commit message: simple-truck-collisio

File: models/urdf/simple_truck/simple_truck.urdf (robot description, URDF)
Before this commit: robot simple_truck, 3 links, 2 joints
Links:
- link main: geometry collision box size=16 7.2 2; collision box size=21 6.8 3
